# IAR project pgm.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m16 ATmega16
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: burn.c main.c ring_buffer.c tools.c tools.h uart.c
